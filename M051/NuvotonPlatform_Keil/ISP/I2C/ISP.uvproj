# Keil uVision project ISP.uvproj, settings and files
target I2C_ISP (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SRAM\ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=4 OneElfS=1
  c misc: --bss_threshold=0
  c include: ..\..\Include;..\..\Include\Driver;..\..\Include\System;..\..\Include\USB;..\..\..\CMSIS\ARMCM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Startup
    ../../../CMSIS/ARMCM0/: core_cm0.c system_M05xx.c
    ../../../CMSIS/ARMCM0/startup/arm/: startup_M05xx.s
  group Library
    ./: DrvI2C.c
  group Source
    ./: FMC.c main.c retarget_printf.c
