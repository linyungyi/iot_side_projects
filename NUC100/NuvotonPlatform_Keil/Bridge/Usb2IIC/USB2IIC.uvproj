# Keil uVision project USB2IIC.uvproj, settings and files
target USB2IIC (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USB2IIS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\USB2IIS.bin"
  c flags: Optim=3
  c define: USING_USB
  c include: ..\..\Include;..\..\Include\Driver;..\..\Include\System;..\..\Include\USB;..\..\..\CMSIS\CM0;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Startup
    ../../../CMSIS/CM0/: core_cm0.c system_NUC1xx.c
    ../../../CMSIS/CM0/startup/arm/: startup_NUC1xx.s
  group Library
    ./: HIDDevice.c DrvI2C.c retarget.c
  group Source
    ./: FMC.c Main.c
