# Keil uVision project ISP.uvproj, settings and files
target UDC_ISP (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: UDC_ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4
  c misc: --bss_threshold=0
  c include: ..\..\Include;..\..\Include\Driver;..\..\Include\System;..\..\Include\USB;..\..\..\CMSIS\CM0;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../CMSIS/CM0/: core_cm0.c system_NUC1xx.c
    ../../../CMSIS/CM0/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Main.c
  group Library files
    ./: UDC.c FMC.c FlashProg.c
