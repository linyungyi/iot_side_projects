# Keil uVision project UsbUARTISP.uvproj, settings and files
target USBUART (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP\ISP +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\ISP\ISP_Code_NUC100_v2.3.bin"
  c flags: Optim=3
  c misc: --bss_threshold=0
  c include: ..\..\Include;..\..\Include\Driver;..\..\Include\System;..\..\Include\USB;..\..\..\CMSIS\CM0;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Startup
    ../../../CMSIS/CM0/: core_cm0.c system_NUC1xx.c
    ../../../CMSIS/CM0/startup/arm/: startup_NUC1xx.s
  group Source
    ./: FMC.c Main.c
target UARTOnly (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: as above
  output: ISP\ISP +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\ISP\ISP_Code_NUC100_UARTOnly_v2.3.bin"
  c flags: Optim=3
  c define: UART_ONLY
  c misc: --bss_threshold=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
